# Keil uVision project SPI_916.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ING91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(128000000) CPUTYPE("Cortex-M4") ELITTLE IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff)
  output: SPI_916 +hex
  AfterMake: fromelf.exe --bin -o SPI_916.bin ./output/SPI_916.axf
  AfterMake: fromelf.exe --text -c -o "$L@L.asm" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER, GET_CPU_CLK,  SPI_RW_ONLY_WO_DMA ,NO_SIMU,  SPI_MASTER_TIMER,SPI_RW_ONLY_W_DMA_TFT
  c include: .\src\VenusFTO_Validation_common;.\src\VenusFTO_Validation_common\registers;../../sdk/bundles/typical/inc;../../sdk/bundles/typical/inc/os;../../sdk/src/BSP;../../sdk/src/FWlib;../../sdk/src/StartUP/ing916;../../sdk/src/Tools;../../sdk/src
  library: MicroLIB
  memory RVCT4: ROM 0x2028000 size 0x58000
  memory RVCT9: RAM 0x20005528 size 0x2ad8
  group APP
    ./src/: main.c profile.c spi_spi1_read_write_without_dma.c spi_spi1_read_write_with_dma.c spi_spi1_read_only_write_only_without_dma.c spi_spi1_read_only_write_only_with_dma.c spi_spi0_read_write_without_dma.c spi_spi1_read_write_without_dma_8bit.c spi_spi1_read_write_with_dma_8bit.c spi_spi1_read_only_write_only_with_dma_tft_240_320_16bit.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../sdk/bundles/typical/ING9168xx/: symdefs.m
  group FWlib
    ../../sdk/src/FWlib/: peripheral_uart.c peripheral_pinctrl.c peripheral_sysctrl.c peripheral_timer.c peripheral_ssp.c peripheral_gpio.c peripheral_dma.c
  group Tools
    ../../sdk/src/Tools/: trace.c
software components: CMSIS:CORE 4.3.0
