# Keil uVision project test_spi_int_918.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ING91800 INGCHIPS
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: test_spi_int_918 +hex
  AfterMake: fromelf.exe --bin -o test_spi_int_918.bin ./output/test_spi_int_918.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: ../../sdk/bundles/typical/inc;../../sdk/bundles/typical/inc/os;../../sdk/src/BSP;../../sdk/src/FWlib;../../sdk/src/StartUP/ing918;../../sdk/src/Tools;../../sdk/src
  library: MicroLIB
  memory RVCT4: ROM 163840 size 376832
  memory RVCT9: RAM 536900896 size 35552
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../sdk/bundles/typical/ING9188xx/: symdefs.m
  group FWlib
    ../../sdk/src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c
