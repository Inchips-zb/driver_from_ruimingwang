# Keil uVision project test_spi_int_918.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ING91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: test_spi_int_918 +hex
  AfterMake: fromelf.exe --bin -o test_spi_int_918.bin ./output/test_spi_int_918.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER  SPI_CS_MAN  SIMU
  c include: ../../sdk/bundles/typical/inc;../../sdk/bundles/typical/inc/os;../../sdk/src/BSP;../../sdk/src/FWlib;../../sdk/src/StartUP/ing918;../../sdk/src/Tools;../../sdk/src
  library: MicroLIB
  memory RVCT4: ROM 0x28000 size 0x5c000
  memory RVCT9: RAM 0x20007520 size 0x8ae0
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../sdk/bundles/typical/ING9188xx/: symdefs.m
  group FWlib
    ../../sdk/src/FWlib/: peripheral_gpio.c peripheral_pinctrl.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c
software components: CMSIS:CORE 4.3.0
