# Keil uVision project IR_916.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ING91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff) CPUTYPE("Cortex-M4") FPU2 CLOCK(12800000) ELITTLE
  output: IR_916 +hex
  AfterMake: fromelf.exe --bin -o IR_916.bin ./output/IR_916.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,  NO_SIMU, IR_RX
  c include: .\src\VenusFTO_Validation_common;.\src\VenusFTO_Validation_common\registers;../../sdk/bundles/typical/inc;../../sdk/bundles/typical/inc/os;../../sdk/src/BSP;../../sdk/src/FWlib;../../sdk/src/StartUP/ing916;../../sdk/src/Tools;../../sdk/src
  library: MicroLIB
  memory RVCT4: ROM 0x2028000 size 0x58000
  memory RVCT9: RAM 0x20005528 size 0x2ad8
  group APP
    ./src/: main.c profile.c
    ./src/VenusFTO_Validation_common/: common.c
  group StartUP
    ./src/: startup_ing91600.s
    ../../sdk/bundles/typical/ING9168xx/: symdefs.m
  group FWlib
    ../../sdk/src/FWlib/: peripheral_uart.c peripheral_pinctrl.c peripheral_sysctrl.c peripheral_timer.c peripheral_ir.c
  group Tools
    ../../sdk/src/Tools/: trace.c
software components: CMSIS:CORE 4.3.0
