# Keil uVision project hengdian_sync_noos_peripheral.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ING91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: hengdian_sync_noos_peripheral +hex
  AfterMake: fromelf.exe --bin -o hengdian_sync_noos_peripheral.bin ./output/hengdian_sync_noos_peripheral.axf
  AfterMake: fromelf.exe --text -c -o "$L@L.asm" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,TEST_SYNC_GPIO_SIMU,V2 PROFILE_DEBUG_2,TRIGGER_MODE_V0
  c include: ../../sdk/bundles/noos_extension/inc;../../sdk/bundles/noos_extension/inc/os;../../sdk/src/BSP;../../sdk/src/FWlib;../../sdk/src/StartUP/ing918;../../sdk/src/Tools;../../sdk/src
  library: MicroLIB
  memory RVCT4: ROM 0x24000 size 0x60000
  memory RVCT9: RAM 0x20001598 size 0xea68
  group APP
    ./src/: main.c profile.c noos_impl.c time_sync.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../sdk/bundles/noos_extension/ING9187xx/: symdefs.m
  group FWlib
    ../../sdk/src/FWlib/: peripheral_uart.c peripheral_pinctrl.c peripheral_sysctrl.c peripheral_timer.c peripheral_gpio.c
software components: CMSIS:CORE 4.3.0
