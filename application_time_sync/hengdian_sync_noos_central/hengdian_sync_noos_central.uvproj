# Keil uVision project hengdian_sync_noos_central.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ING91800 INGCHIPS
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: hengdian_sync_noos_central +hex
  AfterMake: fromelf.exe --bin -o hengdian_sync_noos_central.bin ./output/hengdian_sync_noos_central.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: ../../sdk/bundles/noos_extension/inc;../../sdk/bundles/noos_extension/inc/os;../../sdk/src/BSP;../../sdk/src/FWlib;../../sdk/src/StartUP/ing918;../../sdk/src/Tools;../../sdk/src
  library: MicroLIB
  memory RVCT4: ROM 147456 size 393216
  memory RVCT9: RAM 536876440 size 60008
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../sdk/bundles/noos_extension/ING9187xx/: symdefs.m
  group FWlib
    ../../sdk/src/FWlib/: peripheral_uart.c peripheral_pinctrl.c peripheral_sysctrl.c
  group Tools
    ../../sdk/src/Tools/: ad_parser.c
