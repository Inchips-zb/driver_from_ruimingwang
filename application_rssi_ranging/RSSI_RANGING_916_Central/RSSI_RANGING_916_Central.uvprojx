# Keil uVision project RSSI_RANGING_916_Central.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ing91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(128000000) CPUTYPE("Cortex-M4") FPU2 ELITTLE IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff)
  output: RSSI_RANGING_916_Central +hex
  AfterMake: fromelf.exe --bin -o RSSI_RANGING_916_Central.bin ./output/RSSI_RANGING_916_Central.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER  RSSI_CONNECTION  ALG_KALMAN
  c include: ../../sdk/bundles/typical/inc;../../sdk/bundles/typical/inc/os;../../sdk/src/BSP;../../sdk/src/FWlib;../../sdk/src/StartUP/ing916;../../sdk/src/Tools;../../sdk/src
  library: MicroLIB
  memory RVCT4: ROM 0x2028000 size 0x58000
  memory RVCT9: RAM 0x20005528 size 0x2ad8
  group APP
    ./src/: main.c profile.c ranging.c
  group StartUP
    ./src/: startup_ing91600.s
    ../../sdk/bundles/typical/ING9168xx/: symdefs.m
  group FWlib
    ../../sdk/src/FWlib/: peripheral_gpio.c peripheral_pinctrl.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c
  group Tools
    ../../sdk/src/Tools/: ad_parser.c trace.c
software components: CMSIS:CORE 4.3.0
