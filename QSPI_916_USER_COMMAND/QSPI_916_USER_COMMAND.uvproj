# Keil uVision project QSPI_916_USER_COMMAND.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ING91600 INGCHIPS
  cpu: CLOCK(128000000) CPUTYPE("Cortex-M4") FPU2 ELITTLE IROM(0x2000000-0x2200000) IRAM(0x20000000-0x20008000)
  output: QSPI_916_USER_COMMAND +hex
  AfterMake: fromelf.exe --bin -o QSPI_916_USER_COMMAND.bin ./output/QSPI_916_USER_COMMAND.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: ../../sdk/bundles/typical/inc;../../sdk/bundles/typical/inc/os;../../sdk/src/BSP;../../sdk/src/FWlib;../../sdk/src/StartUP/ing916;../../sdk/src/Tools;../../sdk/src
  library: MicroLIB
  memory RVCT4: ROM 33718272 size 360448
  memory RVCT9: RAM 536892400 size 11280
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing91600.s
    ../../sdk/bundles/typical/ING9168xx/: symdefs.m
  group BSP
    ../../sdk/src/BSP/: eflash.c
  group FWlib
    ../../sdk/src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c peripheral_comparator.c peripheral_dma.c peripheral_efuse.c peripheral_i2s.c peripheral_ir.c peripheral_keyscan.c peripheral_pdm.c peripheral_pte.c peripheral_qdec.c peripheral_usb.c
